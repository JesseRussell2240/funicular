# Keil uVision project funicular.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: utility.c utility.h main.c SysClock.h UART.c UART.h DriveMotor.h DriveMotor_Briefing.c Encoder.c Encoder.h keypad.c keypad.h lcd.c lcd.h PushButton.c PushButton.h RCServo.h RCServoSkeleton.c stepper.c stepper.h UltraSonic.c UltraSonic.h startup_stm32f303xe.s SysClock.c system_stm32f3xx.c LimitSwitch.c LimitSwitch.h UART3.c UART3.h UART1.c UART1.h
software components: CMSIS:CORE 5.6.0
